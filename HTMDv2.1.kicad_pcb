# Repository hamuchan214/HTMDv2.1

## KiCad design HTMDv2.1.kicad_pcb

Parts:
C1: 1000u; CP_Radial_D10.0mm_P5.00mm
C2, C3: 1u; C_0402_1005Metric
C7, C8, C9, C11, C13, C14, C21, C22, C24, C26: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10, C12, C20, C23, C25, C27: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C15, C16, C17, C19: 0.1u; C_0402_1005Metric
C18: 10u; C_0805_2012Metric
D1: D; SS2040FL
D6, D7, D8: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
IC1: TJA1441AT_0Z; SOIC127P600X175-8N; Mouser Part Number 771-TJA1441AT/0Z
IC2, IC3: A3921KLPTR-T; A3944KLPTRT; Manufacturer_Part_Number A3921KLPTR-T
J1, J2: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Vertical
J3: MothreCANConn; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
J4, J5: XT60PW-F; XT30PW-F; PARTREV V1.2
J6: Conn_01x06; JST_XH_S6B-XH-A_1x06_P2.50mm_Horizontal
JP1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R3, R4, R12, R13, R14, R15: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R7: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R11: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R20, R21, R22, R23, R28, R29, R30, R31: 10k; R_0603_1608Metric
R9: 20k; R_0603_1608Metric
R10: 120; R_0603_1608Metric
R16, R17, R34: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R18, R19, R24, R25, R26, R27, R32, R33: 10; R_0603_1608Metric
SW1, SW2, SW3: SW_Push; SKRPABE010
State1.1, State1.2, State2.1, State2.2: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1: ADP3338AKCZ-3.3; SOT230P700X180-4N; MPN ADP3338AKCZ-3.3
U3, U5: ADUM140E0BRWZ-RL; ADuM140ER
U7: ESP32-PICO-D4
U13, U14, U15, U16, U19, U20, U21, U22: SQJ180EP-T1_GE3; PowerPAK1212-8

Connections:
+3.3V: C3.1, C17.1, C18.1, D1.2 (A), IC1.5 (VIO), J6.1, R8.1, U1.2 (OUT), U3.1 (VDD1), U5.1 (VDD1), U7.1 (VDDA), U7.3 (VDDA3P3), U7.4 (VDDA3P3), U7.19 (VDD3P3_RTC), U7.37 (VDD3P3_CPU), U7.43 (VDDA), U7.46 (VDDA)
+5V: C10.1, C11.1, IC3.20 (V5), R5.1, State2.1.2 (A), State2.2.2 (A), U5.16 (VDD2)
+5VA: C14.1, C20.1, IC2.20 (V5), R7.1, State1.1.2 (A), State1.2.2 (A), U3.16 (VDD2)
+24V: C1.1, C12.1, C23.1, IC2.13 (VBB), IC3.13 (VBB), J1.1, J1.2, J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, J1.9, J1.10, J1.11, J1.12, J1.13, J1.14, J1.15, J1.16, J1.17, J1.18, J1.19, J1.20, R1.1, R14.1, U13.2, U16.2, U19.2, U22.2
BOOT: C15.1, J6.5, SW1.2, U7.23 (IO0)
CANH: IC1.7 (CANH), J2.39, J3.3, R10.1
CANL: IC1.6 (CANL), J2.37, J3.2, JP1.2 (B)
CANRX: IC1.4 (RXD), U7.25 (IO16)
CANTX: IC1.1 (TXD), U7.27 (IO17)
CP1: C13.2, IC2.15 (CP2)
CP2: C9.2, IC3.15 (CP2)
EN: C16.1, J6.4, R8.2, SW2.2, U7.9 (EN)
GHA: IC3.10 (GHA), R26.1
GHA0: IC2.10 (GHA), R18.1
GHB: IC3.5 (GHB), R32.1
GHB0: IC2.5 (GHB), R24.1
GLA: IC3.12 (GLA), R27.1
GLA0: IC2.12 (GLA), R19.1
GLB: IC3.3 (GLB), R33.1
GLB0: IC2.3 (GLB), R25.1
GND: C2.2, C3.2, C15.2, C16.2, C17.2, C18.2, C19.2, D6.1 (K), D7.1 (K), D8.1 (K), IC1.2 (GND), IC1.8 (S), J2.13, J2.15, J2.17, J2.19, J2.21, J2.23, J2.25, J2.27, J2.29, J2.31, J2.33, J2.35, J3.1, J6.6, R9.2, SW1.1, SW2.1, U1.1 (GND), U3.2 (GND1), U3.8 (GND1), U5.2 (GND1), U5.8 (GND1), U7.49 (GND)
GNDPWR: C1.2, C10.2, C11.2, C12.2, C14.2, C20.2, C23.2, C24.2, C25.2, C26.2, C27.2, IC2.1 (VDRAIN), IC2.2 (LSS), IC2.17 (GND), IC2.29 (EP), IC3.1 (VDRAIN), IC3.2 (LSS), IC3.17 (GND), IC3.29 (EP), J1.21, J1.22, J1.23, J1.24, J1.25, J1.26, J1.27, J1.28, J1.29, J1.30, J1.31, J1.32, J1.33, J1.34, J1.35, J1.36, J1.37, J1.38, J1.39, J1.40, R4.2, R6.2, R11.2, R15.2, R21.2, R23.2, R29.2, R31.2, SW3.1, U3.9 (GND2), U3.15 (GND2), U5.9 (GND2), U5.15 (GND2), U14.3, U15.3, U20.3, U21.3
LED1: R16.2, U7.20 (IO13)
LED2: R17.2, U7.21 (IO15)
LED3: R34.2, U7.24 (IO4)
unnamed: D6.2 (A), R16.1
unnamed: D7.2 (A), R17.1
unnamed: D8.2 (A), R34.1
unnamed: C22.2, IC2.6 (CB)
unnamed: C13.1, IC2.16 (CP1)
unnamed: IC2.25 (FF1), R13.2
unnamed: IC2.26 (FF2), R12.2
unnamed: IC2.27 (RDEAD), R15.1
unnamed: C21.2, IC2.11 (SA)
unnamed: IC2.28 (VDSTH), R7.2, R11.1
unnamed: C26.1, C27.1, IC2.8 (VREG)
unnamed: C7.2, IC3.6 (CB)
unnamed: C9.1, IC3.16 (CP1)
unnamed: IC3.25 (FF1), R2.2
unnamed: IC3.26 (FF2), R3.2
unnamed: IC3.27 (RDEAD), R4.1
unnamed: C8.2, IC3.11 (SA)
unnamed: IC3.28 (VDSTH), R5.2, R6.1
unnamed: C24.1, C25.1, IC3.8 (VREG)
unnamed: JP1.1 (A), R10.2
unnamed: R18.2, R20.1, U13.1
unnamed: R19.2, R21.1, U14.1
unnamed: R22.1, R24.2, U16.1
unnamed: R23.1, R25.2, U15.1
unnamed: R26.2, R28.1, U19.1
unnamed: R27.2, R29.1, U20.1
unnamed: R30.1, R32.2, U22.1
unnamed: R31.1, R33.2, U21.1
unnamed: R13.1, State1.1.1 (K)
unnamed: R12.1, State1.2.1 (K)
unnamed: R2.1, State2.1.1 (K)
unnamed: R3.1, State2.2.1 (K)
unnamed: R9.1, U7.18 (IO12)
OPHASE1: U3.3 (VIA), U7.17 (IO14)
OPHASE2: U5.3 (VIA), U7.13 (IO33)
OPWMH1: U3.6 (VID), U7.14 (IO25)
OPWMH2: U5.6 (VID), U7.10 (IO34)
OPWML1: U3.5 (VIC), U7.15 (IO26)
OPWML2: U5.5 (VIC), U7.11 (IO35)
OSR1: U3.4 (VIB), U7.16 (IO27)
OSR2: U5.4 (VIB), U7.12 (IO32)
PHASE1: IC2.19 (PHASE), U3.14 (VOA)
PHASE2: IC3.19 (PHASE), U5.14 (VOA)
PWMH1: IC2.23 (PWMH), U3.11 (VOD)
PWMH2: IC3.23 (PWMH), U5.11 (VOD)
PWML1: IC2.22 (PWML), U3.12 (VOC)
PWML2: IC3.22 (PWML), U5.12 (VOC)
RESET: IC2.24 (RESET), IC3.24 (RESET), R1.2, R14.2, SW3.2
RXD: J6.2, U7.40 (U0RXD)
SA1: C21.1, IC2.9 (CA), J4.2, R20.2, U13.3, U14.2
SA2: C8.1, IC3.9 (CA), J5.2, R28.2, U19.3, U20.2
SB1: C22.1, IC2.4 (SB), J4.1, R22.2, U15.2, U16.3
SB2: C7.1, IC3.4 (SB), J5.1, R30.2, U21.2, U22.3
SR1: IC2.21 (SR), U3.13 (VOB)
SR2: IC3.21 (SR), U5.13 (VOB)
TXD: J6.3, U7.41 (U0TXD)
VCC: C2.1, C19.1, D1.1 (K), IC1.3 (VCC), J2.1, J2.2, J2.3, J2.4, J2.5, J2.6, J2.7, J2.8, J2.9, J2.10, J2.11, J2.12, J2.14, J2.16, J2.18, J2.20, J2.22, J2.24, J2.26, J2.28, J2.30, J2.32, J2.34, U1.3 (IN)

Notes on the sheet:
MCU
電源ライン
ゲートドライバ,Hブリッジ
BOOTSW
起動遅延
リセットSW
CANトランシーバー

Board: 4 copper layers, 90.0 x 55.0 mm, 91 parts (11 on the bottom side), 82 nets.

## Commit log

2023-05-14 Artwork finish

Notices in the files:
parts and their libraries:
Copyright 2021 Accelerated Designs. All rights reserved.
